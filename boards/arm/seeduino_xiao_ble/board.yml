## boards/arm/seeduino_xiao_ble/seeeduino_xiao_ble_defconfig
```kconfig
CONFIG_SOC_SERIES_NRF52X=y
CONFIG_BOARD_NRF52840=y
CONFIG_USB=y
CONFIG_GPIO=y
CONFIG_SERIAL=y
```
